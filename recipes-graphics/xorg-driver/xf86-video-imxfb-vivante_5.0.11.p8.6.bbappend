# As per meta-freescale commit 927b31771dab ("xf86-video-imx-vivante: Remove fb
# from name") this recipe got renamed and should no longer be used!

COMPATIBLE_MACHINE  = "(-)"
