#include conf/tdx_version.conf
FILESEXTRAPATHS_prepend := "${THISDIR}/linux-toradex-4.1-2.0.x:"

#LOCALVERSION = "-${PR}"
#PR = "${TDX_VER_INT}"

#SRCREV = "98b774f93e5d5167321734fd114c6570e804b7b2"
#SRCBRANCH = "toradex_4.1-2.0.x-imx-next"
